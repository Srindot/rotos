/*
 * rt_font.c - 5x7 font. Each glyph row is 5 bits, MSB = leftmost column.
 */
#include "rt_font.h"

#include "rn/rn_types.h"

#define MAX_TEXT 128

typedef struct {
    char ch;
    uint8_t rows[RT_FONT_H_PX];
} Glyph;

static const Glyph GLYPHS[] = {
    {'0', {0x0Eu, 0x11u, 0x13u, 0x15u, 0x19u, 0x11u, 0x0Eu}},
    {'1', {0x04u, 0x0Cu, 0x04u, 0x04u, 0x04u, 0x04u, 0x0Eu}},
    {'2', {0x0Eu, 0x11u, 0x01u, 0x02u, 0x04u, 0x08u, 0x1Fu}},
    {'3', {0x1Fu, 0x02u, 0x04u, 0x02u, 0x01u, 0x11u, 0x0Eu}},
    {'4', {0x02u, 0x06u, 0x0Au, 0x12u, 0x1Fu, 0x02u, 0x02u}},
    {'5', {0x1Fu, 0x10u, 0x1Eu, 0x01u, 0x01u, 0x11u, 0x0Eu}},
    {'6', {0x06u, 0x08u, 0x10u, 0x1Eu, 0x11u, 0x11u, 0x0Eu}},
    {'7', {0x1Fu, 0x01u, 0x02u, 0x04u, 0x08u, 0x08u, 0x08u}},
    {'8', {0x0Eu, 0x11u, 0x11u, 0x0Eu, 0x11u, 0x11u, 0x0Eu}},
    {'9', {0x0Eu, 0x11u, 0x11u, 0x0Fu, 0x01u, 0x02u, 0x0Cu}},
    {'A', {0x0Eu, 0x11u, 0x11u, 0x1Fu, 0x11u, 0x11u, 0x11u}},
    {'B', {0x1Eu, 0x11u, 0x11u, 0x1Eu, 0x11u, 0x11u, 0x1Eu}},
    {'C', {0x0Eu, 0x11u, 0x10u, 0x10u, 0x10u, 0x11u, 0x0Eu}},
    {'D', {0x1Eu, 0x11u, 0x11u, 0x11u, 0x11u, 0x11u, 0x1Eu}},
    {'E', {0x1Fu, 0x10u, 0x10u, 0x1Eu, 0x10u, 0x10u, 0x1Fu}},
    {'F', {0x1Fu, 0x10u, 0x10u, 0x1Eu, 0x10u, 0x10u, 0x10u}},
    {'G', {0x0Eu, 0x11u, 0x10u, 0x17u, 0x11u, 0x11u, 0x0Fu}},
    {'H', {0x11u, 0x11u, 0x11u, 0x1Fu, 0x11u, 0x11u, 0x11u}},
    {'I', {0x1Cu, 0x08u, 0x08u, 0x08u, 0x08u, 0x08u, 0x1Cu}},
    {'J', {0x07u, 0x02u, 0x02u, 0x02u, 0x02u, 0x12u, 0x0Cu}},
    {'K', {0x11u, 0x12u, 0x14u, 0x18u, 0x14u, 0x12u, 0x11u}},
    {'L', {0x10u, 0x10u, 0x10u, 0x10u, 0x10u, 0x10u, 0x1Fu}},
    {'M', {0x11u, 0x1Bu, 0x15u, 0x15u, 0x11u, 0x11u, 0x11u}},
    {'N', {0x11u, 0x11u, 0x19u, 0x15u, 0x13u, 0x11u, 0x11u}},
    {'O', {0x0Eu, 0x11u, 0x11u, 0x11u, 0x11u, 0x11u, 0x0Eu}},
    {'P', {0x1Eu, 0x11u, 0x11u, 0x1Eu, 0x10u, 0x10u, 0x10u}},
    {'Q', {0x0Eu, 0x11u, 0x11u, 0x11u, 0x15u, 0x12u, 0x0Du}},
    {'R', {0x1Eu, 0x11u, 0x11u, 0x1Eu, 0x14u, 0x12u, 0x11u}},
    {'S', {0x0Fu, 0x10u, 0x10u, 0x0Eu, 0x01u, 0x01u, 0x1Eu}},
    {'T', {0x1Fu, 0x04u, 0x04u, 0x04u, 0x04u, 0x04u, 0x04u}},
    {'U', {0x11u, 0x11u, 0x11u, 0x11u, 0x11u, 0x11u, 0x0Eu}},
    {'V', {0x11u, 0x11u, 0x11u, 0x11u, 0x11u, 0x0Au, 0x04u}},
    {'W', {0x11u, 0x11u, 0x11u, 0x15u, 0x15u, 0x15u, 0x0Au}},
    {'X', {0x11u, 0x11u, 0x0Au, 0x04u, 0x0Au, 0x11u, 0x11u}},
    {'Y', {0x11u, 0x11u, 0x0Au, 0x04u, 0x04u, 0x04u, 0x04u}},
    {'Z', {0x1Fu, 0x01u, 0x02u, 0x04u, 0x08u, 0x10u, 0x1Fu}},
    {'.', {0x00u, 0x00u, 0x00u, 0x00u, 0x00u, 0x18u, 0x18u}},
    {',', {0x00u, 0x00u, 0x00u, 0x00u, 0x18u, 0x08u, 0x10u}},
    {':', {0x00u, 0x18u, 0x18u, 0x00u, 0x18u, 0x18u, 0x00u}},
    {'-', {0x00u, 0x00u, 0x00u, 0x1Eu, 0x00u, 0x00u, 0x00u}},
    {'/', {0x01u, 0x01u, 0x02u, 0x04u, 0x08u, 0x10u, 0x10u}},
    {'\'', {0x10u, 0x10u, 0x00u, 0x00u, 0x00u, 0x00u, 0x00u}},
    {'(', {0x08u, 0x10u, 0x10u, 0x10u, 0x10u, 0x10u, 0x08u}},
    {')', {0x10u, 0x08u, 0x08u, 0x08u, 0x08u, 0x08u, 0x10u}},
    {'+', {0x00u, 0x04u, 0x04u, 0x1Fu, 0x04u, 0x04u, 0x00u}},
    {'&', {0x0Cu, 0x12u, 0x14u, 0x08u, 0x15u, 0x12u, 0x0Du}},
    {'!', {0x10u, 0x10u, 0x10u, 0x10u, 0x10u, 0x00u, 0x10u}},
    {'?', {0x0Eu, 0x11u, 0x01u, 0x02u, 0x04u, 0x00u, 0x04u}},
    {'%', {0x18u, 0x19u, 0x02u, 0x04u, 0x08u, 0x13u, 0x03u}},
    {'>', {0x10u, 0x08u, 0x04u, 0x02u, 0x04u, 0x08u, 0x10u}},
    {'<', {0x02u, 0x04u, 0x08u, 0x10u, 0x08u, 0x04u, 0x02u}},
    {'#', {0x0Au, 0x1Fu, 0x0Au, 0x0Au, 0x0Au, 0x1Fu, 0x0Au}},
    {'~', {0x0Cu, 0x12u, 0x12u, 0x0Cu, 0x00u, 0x00u, 0x00u}},
};

#define N_GLYPHS ((uint32_t)(sizeof GLYPHS / sizeof GLYPHS[0]))

static const Glyph *find(char ch)
{
    char c = (ch >= 'a' && ch <= 'z') ? (char)(ch - 32) : ch;
    for (uint32_t i = 0u; i < N_GLYPHS; i++) {
        if (GLYPHS[i].ch == c) {
            return &GLYPHS[i];
        }
    }
    return NULL;
}

/* Columns used by a glyph (proportional); digits stay 5 wide, space 3. */
static int32_t glyph_width(const Glyph *g)
{
    if (g == NULL) {
        return 3;
    }
    if (g->ch >= '0' && g->ch <= '9') {
        return 5;
    }
    int32_t w = 0;
    for (uint32_t r = 0u; r < (uint32_t)RT_FONT_H_PX; r++) {
        for (int32_t c = 0; c < 5; c++) {
            if ((g->rows[r] & (0x10u >> c)) != 0u && c + 1 > w) {
                w = c + 1;
            }
        }
    }
    return w;
}

int32_t rt_text_width(const char *s, int32_t scale)
{
    if (!RN_ASSERT(s != NULL) || !RN_ASSERT(scale > 0)) {
        return 0;
    }
    int32_t w = 0;
    for (uint32_t i = 0u; i < (uint32_t)MAX_TEXT && s[i] != '\0'; i++) {
        w += (glyph_width(find(s[i])) + 1) * scale;
    }
    return (w > 0) ? w - scale : 0;
}

static void draw_glyph(RtCanvas *cv, int32_t x, int32_t y, const Glyph *g, int32_t scale, uint8_t color)
{
    for (int32_t r = 0; r < RT_FONT_H_PX; r++) {
        for (int32_t c = 0; c < 5; c++) {
            if ((g->rows[r] & (0x10u >> c)) != 0u) {
                rt_canvas_fill_rect(cv, x + c * scale, y + r * scale, scale, scale, color);
            }
        }
    }
}

static int32_t draw_run(RtCanvas *cv, int32_t x, int32_t y, const char *s, int32_t scale, uint8_t color)
{
    int32_t cx = x;
    for (uint32_t i = 0u; i < (uint32_t)MAX_TEXT && s[i] != '\0'; i++) {
        const Glyph *g = find(s[i]);
        if (g != NULL) {
            draw_glyph(cv, cx, y, g, scale, color);
        }
        cx += (glyph_width(g) + 1) * scale;
    }
    return cx - scale;
}

int32_t rt_text(RtCanvas *cv, int32_t x, int32_t y, const char *s, int32_t scale, uint8_t color, bool shadow)
{
    if (!RN_ASSERT(cv != NULL && s != NULL) || !RN_ASSERT(scale > 0 && scale <= 8)) {
        return x;
    }
    if (shadow) {
        (void)draw_run(cv, x + scale, y + scale, s, scale, RT_C_SHADOW);
    }
    return draw_run(cv, x, y, s, scale, color);
}

int32_t rt_text_centered(RtCanvas *cv, int32_t cx, int32_t y, const char *s, int32_t scale, uint8_t color, bool shadow)
{
    return rt_text(cv, cx - rt_text_width(s, scale) / 2, y, s, scale, color, shadow);
}
