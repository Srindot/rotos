#include "font.h"
#include <cstring>

namespace rotos {

struct Glyph { char ch; const char* rows; };  // 7 rows x 5 cols, '#' = on

static const Glyph GLYPHS[] = {
    {'0', ".###." "#...#" "#..##" "#.#.#" "##..#" "#...#" ".###."},
    {'1', "..#.." ".##.." "..#.." "..#.." "..#.." "..#.." ".###."},
    {'2', ".###." "#...#" "....#" "...#." "..#.." ".#..." "#####"},
    {'3', "#####" "...#." "..#.." "...#." "....#" "#...#" ".###."},
    {'4', "...#." "..##." ".#.#." "#..#." "#####" "...#." "...#."},
    {'5', "#####" "#...." "####." "....#" "....#" "#...#" ".###."},
    {'6', "..##." ".#..." "#...." "####." "#...#" "#...#" ".###."},
    {'7', "#####" "....#" "...#." "..#.." ".#..." ".#..." ".#..."},
    {'8', ".###." "#...#" "#...#" ".###." "#...#" "#...#" ".###."},
    {'9', ".###." "#...#" "#...#" ".####" "....#" "...#." ".##.."},
    {'A', ".###." "#...#" "#...#" "#####" "#...#" "#...#" "#...#"},
    {'B', "####." "#...#" "#...#" "####." "#...#" "#...#" "####."},
    {'C', ".###." "#...#" "#...." "#...." "#...." "#...#" ".###."},
    {'D', "####." "#...#" "#...#" "#...#" "#...#" "#...#" "####."},
    {'E', "#####" "#...." "#...." "####." "#...." "#...." "#####"},
    {'F', "#####" "#...." "#...." "####." "#...." "#...." "#...."},
    {'G', ".###." "#...#" "#...." "#.###" "#...#" "#...#" ".####"},
    {'H', "#...#" "#...#" "#...#" "#####" "#...#" "#...#" "#...#"},
    {'I', "###.." ".#..." ".#..." ".#..." ".#..." ".#..." "###.."},
    {'J', "..###" "...#." "...#." "...#." "...#." "#..#." ".##.."},
    {'K', "#...#" "#..#." "#.#.." "##..." "#.#.." "#..#." "#...#"},
    {'L', "#...." "#...." "#...." "#...." "#...." "#...." "#####"},
    {'M', "#...#" "##.##" "#.#.#" "#.#.#" "#...#" "#...#" "#...#"},
    {'N', "#...#" "#...#" "##..#" "#.#.#" "#..##" "#...#" "#...#"},
    {'O', ".###." "#...#" "#...#" "#...#" "#...#" "#...#" ".###."},
    {'P', "####." "#...#" "#...#" "####." "#...." "#...." "#...."},
    {'Q', ".###." "#...#" "#...#" "#...#" "#.#.#" "#..#." ".##.#"},
    {'R', "####." "#...#" "#...#" "####." "#.#.." "#..#." "#...#"},
    {'S', ".####" "#...." "#...." ".###." "....#" "....#" "####."},
    {'T', "#####" "..#.." "..#.." "..#.." "..#.." "..#.." "..#.."},
    {'U', "#...#" "#...#" "#...#" "#...#" "#...#" "#...#" ".###."},
    {'V', "#...#" "#...#" "#...#" "#...#" "#...#" ".#.#." "..#.."},
    {'W', "#...#" "#...#" "#...#" "#.#.#" "#.#.#" "#.#.#" ".#.#."},
    {'X', "#...#" "#...#" ".#.#." "..#.." ".#.#." "#...#" "#...#"},
    {'Y', "#...#" "#...#" ".#.#." "..#.." "..#.." "..#.." "..#.."},
    {'Z', "#####" "....#" "...#." "..#.." ".#..." "#...." "#####"},
    {'.', "....." "....." "....." "....." "....." "##..." "##..."},
    {',', "....." "....." "....." "....." "##..." ".#..." "#...."},
    {':', "....." "##..." "##..." "....." "##..." "##..." "....."},
    {'-', "....." "....." "....." "####." "....." "....." "....."},
    {'/', "....#" "....#" "...#." "..#.." ".#..." "#...." "#...."},
    {'\'', "#...." "#...." "....." "....." "....." "....." "....."},
    {'(', ".#..." "#...." "#...." "#...." "#...." "#...." ".#..."},
    {')', "#...." ".#..." ".#..." ".#..." ".#..." ".#..." "#...."},
    {'+', "....." "..#.." "..#.." "#####" "..#.." "..#.." "....."},
    {'&', ".##.." "#..#." "#.#.." ".#..." "#.#.#" "#..#." ".##.#"},
    {'!', "#...." "#...." "#...." "#...." "#...." "....." "#...."},
    {'?', ".###." "#...#" "....#" "...#." "..#.." "....." "..#.."},
    {'%', "##..." "##..#" "...#." "..#.." ".#..." "#..##" "...##"},
    {'>', "#...." ".#..." "..#.." "...#." "..#.." ".#..." "#...."},
    {'<', "...#." "..#.." ".#..." "#...." ".#..." "..#.." "...#."},
    {'#', ".#.#." "#####" ".#.#." ".#.#." ".#.#." "#####" ".#.#."},
    {'~', ".##.." "#..#." "#..#." ".##.." "....." "....." "....."},   // degree sign
};

static const Glyph* find(char ch) {
    if (ch >= 'a' && ch <= 'z') ch = char(ch - 32);
    for (const Glyph& g : GLYPHS) if (g.ch == ch) return &g;
    return nullptr;
}

// Columns actually used by a glyph (proportional width); digits stay 5 wide.
static int glyphWidth(const Glyph* g) {
    if (!g) return 3;  // space / unknown
    if (g->ch >= '0' && g->ch <= '9') return 5;
    int w = 0;
    for (int r = 0; r < 7; ++r)
        for (int c = 0; c < 5; ++c)
            if (g->rows[r * 5 + c] == '#' && c + 1 > w) w = c + 1;
    return w;
}

int textWidth(const char* s, int scale) {
    int w = 0;
    for (; *s; ++s) w += (glyphWidth(find(*s)) + 1) * scale;
    return w ? w - scale : 0;
}

static int drawRun(Canvas& cv, int x, int y, const char* s, int scale, uint8_t color) {
    for (; *s; ++s) {
        const Glyph* g = find(*s);
        if (g)
            for (int r = 0; r < 7; ++r)
                for (int c = 0; c < 5; ++c)
                    if (g->rows[r * 5 + c] == '#') cv.fillRect(x + c * scale, y + r * scale, scale, scale, color);
        x += (glyphWidth(g) + 1) * scale;
    }
    return x - scale;
}

int drawText(Canvas& cv, int x, int y, const char* s, int scale, uint8_t color, bool shadow) {
    if (shadow) drawRun(cv, x + scale, y + scale, s, scale, C_SHADOW);
    return drawRun(cv, x, y, s, scale, color);
}

int drawTextCentered(Canvas& cv, int cx, int y, const char* s, int scale, uint8_t color, bool shadow) {
    return drawText(cv, cx - textWidth(s, scale) / 2, y, s, scale, color, shadow);
}

} // namespace rotos
