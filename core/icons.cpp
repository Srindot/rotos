#include "icons.h"

namespace rotos {

using Sprite = const char* const[16];

static Sprite STRAIGHT = {
    "................", ".......##.......", "......####......", ".....######.....",
    "....########....", "...##########...", "......####......", "......####......",
    "......####......", "......####......", "......####......", "......####......",
    "......####......", "......####......", "......####......", "................"};
static Sprite LEFT = {
    "................", ".....#..........", "....##..........", "...###..........",
    "..###########...", ".############...", "..###########...", "...###....###...",
    "....##....###...", ".....#....###...", "..........###...", "..........###...",
    "..........###...", "..........###...", "..........###...", "................"};
static Sprite SLIGHT_LEFT = {
    "................", "..#######.......", "..######........", "..#####.........",
    "..######........", "..###.###.......", "..##...###......", "..#.....###.....",
    ".........###....", "..........###...", "..........###...", "..........###...",
    "..........###...", "..........###...", "..........###...", "................"};
static Sprite SHARP_LEFT = {
    "................", "................", ".........####...", "........#####...",
    ".......######...", "......###.###...", "..#..###..###...", "..#####...###...",
    "..###.....###...", "..####....###...", "..#####...###...", "..######..###...",
    "..#######.###...", "..........###...", "..........###...", "................"};
static Sprite UTURN_LEFT = {
    "................", "....######......", "...########.....", "..###....###....",
    "..###....###....", "..###....###....", "..###....###....", "..###....###....",
    "..###....###....", "#######..###....", ".#####...###....", "..###....###....",
    "...#.....###....", ".........###....", ".........###....", "................"};
static Sprite ROUNDABOUT = {
    "................", "................", "...#####........", "..#######...#...",
    ".###...###..##..", ".##.....#######.", ".##.....########", ".##.....#######.",
    ".###...###..##..", "..#######...#...", "...#####........", "....###.........",
    "....###.........", "....###.........", "....###.........", "................"};
static Sprite ARRIVE = {
    "................", ".....######.....", "....########....", "...###....###...",
    "...##......##...", "...##......##...", "...###....###...", "....########....",
    ".....######.....", "......####......", "......####......", ".......##.......",
    ".......##.......", "................", "....########....", "................"};

void drawManeuverIcon(Canvas& cv, int x, int y, ManeuverType t, int scale, uint8_t color) {
    const char* const* s = STRAIGHT;
    bool mirror = false;
    switch (t) {
        case M_LEFT: s = LEFT; break;
        case M_RIGHT: s = LEFT; mirror = true; break;
        case M_SLIGHT_LEFT: case M_FORK_LEFT: case M_RAMP_LEFT: s = SLIGHT_LEFT; break;
        case M_SLIGHT_RIGHT: case M_FORK_RIGHT: case M_RAMP_RIGHT: s = SLIGHT_LEFT; mirror = true; break;
        case M_SHARP_LEFT: s = SHARP_LEFT; break;
        case M_SHARP_RIGHT: s = SHARP_LEFT; mirror = true; break;
        case M_UTURN_LEFT: s = UTURN_LEFT; break;
        case M_UTURN_RIGHT: s = UTURN_LEFT; mirror = true; break;
        case M_ROUNDABOUT_LEFT: s = ROUNDABOUT; break;
        case M_ROUNDABOUT_RIGHT: s = ROUNDABOUT; mirror = true; break;
        case M_ARRIVE: s = ARRIVE; break;
        default: break;
    }
    for (int r = 0; r < 16; ++r)
        for (int c = 0; c < 16; ++c)
            if (s[r][mirror ? 15 - c : c] == '#') cv.fillRect(x + c * scale, y + r * scale, scale, scale, color);
}

// ── Weather ───────────────────────────────────────────────────────────
// '#' = C_TEXT, '+' = C_ACCENT
static Sprite W_SUN = {
    "................", ".......##.......", "..#....##....#..", "...#........#...",
    "......####......", ".....######.....", "....########....", ".##.########.##.",
    ".##.########.##.", "....########....", ".....######.....", "......####......",
    "...#........#...", "..#....##....#..", ".......##.......", "................"};
static Sprite W_MOON = {
    "................", ".....#####......", "...####.....+...", "..###...........",
    ".###............", ".###.........+..", "###.............", "###.............",
    "###.............", "###.............", ".###...........#", ".####........##.",
    "..#####....###..", "...##########...", ".....######.....", "................"};
static Sprite W_PARTLY = {
    "................", "..........+.....", "......+..+++..+.", ".......+++++++..",
    "......+++++++++.", "....###++++++++.", "...#####+++++++.", "..#######+++++..",
    ".##########.....", "############....", "#############...", "##############..",
    "##############..", ".############...", "................", "................"};
static Sprite W_CLOUD = {
    "................", "................", "................", "......####......",
    ".....######.....", "..##.#######....", ".############...", "##############..",
    "###############.", "################", "################", ".###############",
    "..#############.", "................", "................", "................"};
static Sprite W_FOG = {
    "................", "................", "..############..", "................",
    "####.######.####", "................", "..############..", "................",
    "#########.######", "................", "..############..", "................",
    "####.######.####", "................", "................", "................"};
static Sprite W_RAIN = {
    "................", "......####......", ".....######.....", "..##.#######....",
    ".############...", "##############..", "###############.", "################",
    ".##############.", "................", "...+...+...+....", "..+...+...+.....",
    "................", ".+...+...+......", "+...+...+.......", "................"};
static Sprite W_STORM = {
    "................", "......####......", ".....######.....", "..##.#######....",
    ".############...", "##############..", "###############.", "################",
    ".######++######.", ".......++.......", "......++........", ".....++++.......",
    ".......++.......", "......++........", ".....++.........", "................"};

const char* weatherName(uint8_t c) {
    if (c == 0) return "CLEAR";
    if (c == 1) return "MOSTLY CLEAR";
    if (c == 2) return "PARTLY CLOUDY";
    if (c == 3) return "CLOUDY";
    if (c == 45 || c == 48) return "FOG";
    if (c >= 51 && c <= 57) return "DRIZZLE";
    if (c == 65 || c == 82) return "HEAVY RAIN";
    if (c >= 61 && c <= 67) return "RAIN";
    if (c >= 80 && c <= 82) return "SHOWERS";
    if (c >= 95) return "THUNDERSTORM";
    return "CLOUDY";
}

static void drawSprite2(Canvas& cv, int x, int y, const char* const* s, int scale) {
    for (int r = 0; r < 16; ++r)
        for (int c = 0; c < 16; ++c) {
            char ch = s[r][c];
            if (ch == '#') cv.fillRect(x + c * scale, y + r * scale, scale, scale, C_TEXT);
            else if (ch == '+') cv.fillRect(x + c * scale, y + r * scale, scale, scale, C_ACCENT);
        }
}

void drawWeatherIcon(Canvas& cv, int x, int y, uint8_t c, bool isDay, int scale) {
    const char* const* s = W_CLOUD;
    if (c <= 1) s = isDay ? W_SUN : W_MOON;
    else if (c == 2) s = W_PARTLY;
    else if (c == 45 || c == 48) s = W_FOG;
    else if (c >= 95) s = W_STORM;
    else if ((c >= 51 && c <= 67) || (c >= 80 && c <= 82)) s = W_RAIN;
    drawSprite2(cv, x, y, s, scale);
}

// ── Flyover arrows ────────────────────────────────────────────────────
void drawFlyoverArrow(Canvas& cv, int x, int y, bool up, uint8_t color) {
    static const char* A[7] = {"...#...", "..###..", ".#####.", "#######", "..###..", "..###..", "..###.."};
    for (int r = 0; r < 7; ++r)
        for (int c = 0; c < 7; ++c)
            if (A[up ? r : 6 - r][c] == '#') cv.pixel(x + c, y + r, color);
}

// ── Mascot (placeholder) ──────────────────────────────────────────────
// 's' shadow, 'a' accent body, 'w' eye white, 'p' pupil, 'h' highlight
static Sprite MASCOT_IDLE = {
    ".......hh.......", ".......hh.......", "........s.......", "....ssssssss....",
    "...saaaaaaaas...", "..saaaaaaaaaas..", "..saawwaawwaas..", "..saawpaawpaas..",
    "..saaaaaaaaaas..", "..saaaassaaaas..", "...saaaaaaaas...", "....ssssssss....",
    ".....s....s.....", "....ss....ss....", "................", "................"};
static Sprite MASCOT_BLINK = {
    ".......hh.......", ".......hh.......", "........s.......", "....ssssssss....",
    "...saaaaaaaas...", "..saaaaaaaaaas..", "..saaaaaaaaaas..", "..saassaassaas..",
    "..saaaaaaaaaas..", "..saaaassaaaas..", "...saaaaaaaas...", "....ssssssss....",
    ".....s....s.....", "....ss....ss....", "................", "................"};
static Sprite MASCOT_HAPPY = {
    ".......hh.......", ".......hh.......", "........s.......", "s...ssssssss...s",
    "as.saaaaaaaas.sa", ".asaaaaaaaaaasa.", "..saasaaaasaas..", "..sasasaasasas..",
    "..saaaaaaaaaas..", "..saaasaasaaas..", "...saaassaaas...", "....ssssssss....",
    ".....s....s.....", "....ss....ss....", "................", "................"};

void drawMascot(Canvas& cv, int x, int y, int mood, int scale) {
    const char* const* s = mood == 2 ? MASCOT_HAPPY : (mood == 1 ? MASCOT_BLINK : MASCOT_IDLE);
    for (int r = 0; r < 16; ++r)
        for (int c = 0; c < 16; ++c) {
            uint8_t col;
            switch (s[r][c]) {
                case 's': col = C_SHADOW; break;
                case 'a': col = C_ACCENT; break;
                case 'w': col = C_TEXT; break;
                case 'p': col = C_SHADOW; break;
                case 'h': col = C_HILITE; break;
                default: continue;
            }
            cv.fillRect(x + c * scale, y + r * scale, scale, scale, col);
        }
}

} // namespace rotos
